# Repository peakhunt/stm32f103rct6_audio

File README.md:

# stm32f103rct6_audio

!!! work still in progress at very early stage!!!

This is a simple audio processor based on stm32f1 as my hobby project.

## Notice
while working on this hobby project, I learned a couple of things.
1. Floating point FFT/iFFT is way too slow for real-time application. This was rather expected since Cortex-M3 comes with no FPU.
2. I am seeing horrible accuracy loss with Q15 fixed point based FFT/iFFT. My calculation shows that I am getting roughly 7% accuracy loss.

So I call it quits at this point and move on to a new project based on STM32F407VET6 board. [See here](https://github.com/peakhunt/stm32f407vet6_audio)

## Current Architecture

## Current Status
### 15th, August, 2018

All right. With oscilloscope at work, I was able to verify Input/Output.
In the picture below, yellow is ADC input and green is DAC output.

### 11th, August, 2018.

Since I don't have an oscilloscope, I couldn't precisely verify all the input/output graphs and their timings.
But with test meter and potentiometer, I was able to verify that the output voltage matches the input voltage.
The next phase is to design audio I/O circuit and apply DSP.

### 3th, October, 2018.

It's been a while since last time I worked on this hobby project.

The input/output side schematic is ready and it is basically just a copy of [electrosmash](https://www.electrosmash.com/pedalshield-uno).

And here is the schematic.

Input side is just an
1. offset biasing around 1.7V since guitar input is around 0V.
2. amplification using TL972 opamp for ADC.

1. just output stabilization using TL972 opamp.

And here is the demo board connected to a cheap stm32f103rct6 board.

And you know what? It doesn't sound that bad!
Now is the time to study DSP a bit.

### 16th, October, 2018.
Noise is a huge issue!!! In my debugging, it is the guitar/amp interface circuit. Working on it now.

## KiCad design hw/guitarif/guitarif.kicad_pcb

Parts:
C1, C4, C5, C6, C10: 6.8nF; C_0603_HandSoldering
C2: 0.1uF; C_0603_HandSoldering
C3, C7, C11: 4.7uF; CP_Radial_D8.0mm_P2.50mm
C8: 270pF; C_0603_HandSoldering
C9: 100nF; C_0603_HandSoldering
J1, J2: Barrel_Jack_Switch; Pin_Header_Straight_1x03_Pitch2.54mm
J3: Conn_01x04; Pin_Header_Straight_1x04_Pitch2.54mm
R1, R3, R5, R6, R7, R9: 4.7K; R_0603_HandSoldering
R2, R4: 1M; R_0603_HandSoldering
R8, R10, R11: 100K; R_0603_HandSoldering
RV1: R_POT_US; Potentiometer_WirePads
U1: Opamp_Dual_Generic; DIP-8_W7.62mm

Connections:
/1V7: C11.1, R4.2, R10.1, R11.2
/3V3: C9.2, J3.1, R10.2, U1.8 (V+)
/ADC_IN: C10.1, J3.3, R9.1
/DAC_OUT: J3.4, R1.2
/GND: C1.1, C3.2, C4.1, C6.1, C9.1, C10.2, C11.2, J1.2, J1.3, J2.2, J2.3, J3.2, R2.2, R11.1, U1.4 (V-)
unnamed: C1.2, R1.1, R3.2
unnamed: C2.1, R4.1, R7.2
unnamed: C2.2, J1.1, R2.1
unnamed: C3.1, R6.2
unnamed: C4.2, R5.1, U1.5 (+)
unnamed: C5.1, R3.1, R5.2
unnamed: C5.2, C7.1, U1.6 (-), U1.7
unnamed: C6.2, R7.1, U1.3 (+)
unnamed: C7.2, J2.1
unnamed: C8.1, R8.1, R9.2, U1.1
unnamed: C8.2, R8.2, RV1.1, U1.2 (-)
unnamed: R6.1, RV1.2

Board: 2 copper layers, 43.0 x 42.4 mm, 27 parts (0 on the bottom side), 17 nets.

## Commit log

2018-07-13 initial import
2018-07-13 adding doc
2018-07-13 README.md update
2018-07-16 adding volatile version of audio buffer for more experiment
2018-08-11 fixed dac data alignment bug
2018-08-11 added adc calibration call
2018-08-11 doc update
2018-10-03 fixed typo in README.md
2018-10-03 prototype board picture update
2018-10-03 readme update
2018-10-03 checked input side schematic error
2018-10-30 removing unnecessary files. adding optimization disable gcc flag to audio_buffer.c
2018-10-30 added volatile to counters
2018-11-06 adding various stats for verification
2018-11-07 moved app_init_f before enabling systick
2019-01-03 added CMSIS DSP library to the project for a starter test.
2019-01-03 added FFT processing skeleton
2019-01-03 switching to complex DFT. trying to figure out why it is so slow.
2019-01-03 adding more ref doc.
2019-01-04 ref doc update
2019-01-04 ref update
2019-01-04 switching to q15 type for FFT. f32 is way to slow on CM3
2019-01-04 migrated to cubemx5
2019-01-04 modified start-up delay. added DSP kernel framework.
2019-01-04 added fft test code to verify input/output format
2019-01-04 finalizing FFT kernel framework
2019-01-04 adding magnitude handling template code
2019-01-04 adding interface H/W PCB design
2019-01-05 another ref doc update
2019-01-16 added scaling factor to compensate accuracy loss
2019-01-17 fixing ifft scale bug. adding bypass shell command for comparison
2019-01-17 addded some commonets on issues for me to remember
2019-01-17 added legacy cfft audio source
2019-01-17 fixed schematic bug in potentiometer
2019-01-17 more comments for better debugging for better accuraccy
2019-01-17 no matter what I do I can't find a way to compensate for the accuracy loss
2019-01-19 calling it a quit with M3 board
